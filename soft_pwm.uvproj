# Keil uVision project soft_pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 51-2nd +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DPWMTMR_SET
  group Source Group 1
    ./: main.c arch.c driver.c f_idle.c led.c
  group Document
    ./: readme.txt
